# Keil uVision project proj.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: ..\source\BSP;..\source\Drv;..\source\BSP\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\source\Startup\proj.sct
  link misc: --keep=*.o(*initcall*)
  group bsp
    ../source/BSP/: stm32f10x_cl.s
    ../source/BSP/STM32F10x/: cortexm3_macro.s
  group main
    ../source/Main/: main.c stm32f10x_it.c
  group drv
    ../source/Drv/: shell.c I2c.c timer.c UART.C Beep.c lib.c esp.c eeprom.c key.c flashIAP.c pwm.c TM1637.c TemperatureInside.c IR.c
    ../source/BSP/: PortDrv.c initcall.c rtc.c
  group Lib
    ../source/BSP/STM32F10x/: stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_nvic.c
